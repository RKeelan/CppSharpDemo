<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IarLib.ewp</path>
    </project>
    <batchBuild />
</workspace>
