# IAR project IarLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Cpp\inc; ..\Cpp\lib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  postbuild: debug-post-build.bat "$PROJ_DIR$"
  ILINK.IlinkOutputFile: IarLib.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group inc
    ../Cpp/inc/: CppData.h CppLib.h CppOp.h
  group lib
    ../Cpp/lib/: CppOp.cpp
